# IAR project Backup of Channel2-inrpt.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\USER; ..\CMT2300\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Channel2-inrpt.hex
  ILINK.IlinkOutputFile: Channel2-inrpt.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group CMT2300
    ../CMT2300/src/: cmt2300.c cmt2300_hal.c radio.c spi.c
  group FWLib
    ../FWlib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group USER
    ../USER/: delay.c key.c main.c stm8s_it.c sysclock.c tim1.c trans433.c
